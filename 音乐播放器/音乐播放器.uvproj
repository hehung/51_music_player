# Keil uVision project 音乐播放器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 音乐播放器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c init.c D1602.c
